Properties of the parts of a building model (IFC4)

# File
Description: Unknown
File name: K855_P002_V02_FIYU Fast 14 Klemmteil
Time: 2025-06-26T10:09:21+02:00
Author: Unknown
Organization: Unknown
Written by: ST-DEVELOPER v20
Made in: Unknown
Authorization: OpenTools
Comment: Generated by software containing ST-Developer * from STEP Tools, Inc. (www.steptools.com)
Comment: OPTION: strings as raw bytes, not using required /X/ escapes
Comment: description
Comment: implementation_level
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorisation

# IfcBuilding, Default Building
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingElementProxy: K855_P002_V02_FIYU Fast 14 Klemmteil
In: Default Building
PredefinedType: ELEMENT
